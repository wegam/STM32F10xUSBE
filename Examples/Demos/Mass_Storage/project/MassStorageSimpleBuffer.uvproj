# Keil uVision project MassStorageSimpleBuffer.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210B_EVAL
  c include: ..\include;..\..\..\..\..\..\INC\ST\STM32F10x\USB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application files
    ../source/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c memory.c msd.c scsi_data.c usb_bot.c usb_endp.c fsmc_nand.c mass_mal.c nand_if.c sdcard.c
  group USBLib
    ../../../../../../RV31/LIB/ST/STM32F10x/USB/: usb_regs.c usb_core.c usb_init.c usb_int.c usb_mem.c
  group FWLib
    ../../../../../../RV31/LIB/ST/: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
  group Doc
    ../: readme.txt
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210E_EVAL
  c include: ..\include;..\..\..\..\..\..\INC\ST\STM32F10x\USB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
